# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,USE_USB_FS
  c include: ..\FW\Include;..\App\Main;..\App\DataType;..\ARM\SysTick;..\ARM\System;..\ARM\NVIC;..\HW\RCU;..\HW\UART0;..\HW\Timer;..\App\LED;..\App\KeyOne;..\App\AT24Cxx;..\HW\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/KeyOne/: KeyOne.c ProcKeyOne.c
    ../App/AT24Cxx/: AT24Cxx.c
  group HW
    ../HW/Timer/: Timer.c
    ../HW/UART0/: Queue.c UART0.c
    ../HW/RCU/: RCU.c
    ../HW/I2C/: I2C.c
  group FW
    ../FW/Source/: gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_i2c.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: gd32f4xx_it.c startup_gd32f450_470.s system_gd32f4xx.c
software components: CMSIS:CORE 5.4.0
