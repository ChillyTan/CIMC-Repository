# Keil uVision project GD32KeilPrj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,USE_USB_FS
  c include: ..\FW\Include;..\ARM\NVIC;..\ARM\System;..\ARM\SysTick;..\HW\RCU;..\HW\SDRAM;..\HW\Timer;..\HW\UART0;..\App\DataType;..\App\EmbGUI\App;..\App\EmbGUI\Module;..\App\EmbGUI\Platform;..\App\EmbGUI\Widget;..\App\IICCommon;..\App\LED;..\App\Main;..\App\Picture;..\App\TLILCD;..\App\Touch;..\App\Audio;..\App\FontLib;..\App\GD25QXX;..\App\KeyOne;..\App\Malloc;..\HW\SPI;..\TPSW\FatFs\src;..\App\SDCard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/TLILCD/: TLILCD.c
    ../App/Picture/: JPEG.c tjpgd.c BMP.c
    ../App/EmbGUI/Widget/: TextWidget.c ButtonWidget.c LineEditWidget.c RadioWidget.c
    ../App/EmbGUI/App/: GUITop.c
    ../App/EmbGUI/Platform/: GUIPlatform.c
    ../App/IICCommon/: IICCommon.c
    ../App/Touch/: GT1151Q.c Touch.c
    ../App/Audio/: AudioTop.c I2S.c Recorder.c WavPlayer.c WM8978.c
    ../App/EmbGUI/Module/: GUIButton.c
    ../App/FontLib/: FontLib.c
    ../App/GD25QXX/: GD25QXX.c
    ../App/KeyOne/: KeyOne.c ProcKeyOne.c
    ../App/Malloc/: Malloc.c
    ../App/SDCard/: SDCard.c
  group HW
    ../HW/Timer/: Timer.c
    ../HW/UART0/: Queue.c UART0.c
    ../HW/RCU/: RCU.c
    ../HW/SDRAM/: SDRAM.c
    ../HW/SPI/: SPI.c
  group TPSW
    ../TPSW/FatFS/src/: diskio.c ff.c
  group FW
    ../FW/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: gd32f4xx_it.c startup_gd32f450_470.s system_gd32f4xx.c
software components: CMSIS:CORE 5.4.0
